PACKAGE_INSTALL += " \
    firmware-imx-sdma-imx6q \
"

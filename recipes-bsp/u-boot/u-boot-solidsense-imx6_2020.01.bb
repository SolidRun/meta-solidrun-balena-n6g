# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP

DESCRIPTION = "U-Boot supporting SolidRun Solidsense i.MX6 based boards."

require recipes-bsp/u-boot/u-boot-solidsense-imx6-common_2020.01.inc

#LOCALVERSION ?= "-${SRCBRANCH}"
